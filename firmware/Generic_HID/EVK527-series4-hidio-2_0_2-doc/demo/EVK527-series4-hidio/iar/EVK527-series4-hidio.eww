<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EVK527-series4-hidio.ewp</path>
  </project>
  <batchBuild/>
</workspace>


