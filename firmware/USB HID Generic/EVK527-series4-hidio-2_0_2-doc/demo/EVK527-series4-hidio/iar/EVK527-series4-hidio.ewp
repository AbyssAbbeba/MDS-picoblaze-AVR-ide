# IAR project EVK527-series4-hidio.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: pe111, pe550, pa082, pa050
  ICCAVR.newCCIncludePaths: ..; ../conf/; ../../../; ../../../../common/
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm32u4s.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../lib_mcu/flash/: flash_drv.s90
    ../: hid_task.c main.c usb_descriptors.c usb_specific_request.c
    ../../../lib_mcu/power/: power_drv.c
    ../../../modules/scheduler/: scheduler.c
    ../../../lib_mcu/util/: start_boot.c
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../../lib_mcu/usb/: usb_drv.c
    ../../../modules/usb/: usb_task.c
    ../../../lib_mcu/wdt/: wdt_drv.c
